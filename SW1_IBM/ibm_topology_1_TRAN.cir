*************************************************************
* 01AUXPE Advanced DEsign for Signal Integrity and Compliance
* Stefano Grivet-Talocia, DET Politecnico di Torino, Italy
* This file generated by SGT on 15-Feb-2023
*************************************************************

*************************************************************
* Evaluating the channel response for testcase IBM_topology_1
*************************************************************

*************************************************************
* Include netlist with all components
.include ibm_topology_1.cir
*************************************************************

*************************************************************
* Directives for simulation
*************************************************************

.TRAN 1n
.SAVE V(D_3p) V(D_4p)

.end

*************************************************************
* 01AUXPE Advanced DEsign for Signal Integrity and Compliance
* Stefano Grivet-Talocia, DET Politecnico di Torino, Italy
* This file generated by SGT on 15-Feb-2023
*************************************************************

*************************************************************
* Evaluating the channel response for testcase IBM_topology_2
*************************************************************

*************************************************************
* Include netlist with all components
.include ibm_topology_2.cir
*************************************************************

*************************************************************
* Directives for simulation
*************************************************************

.AC LIN 2001 0.02G 40G
.PROBE V(N_3p) V(N_4p)

.end

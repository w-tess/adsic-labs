*************************************************************
* 01AUXPE Advanced DEsign for Signal Integrity and Compliance
* Stefano Grivet-Talocia, DET Politecnico di Torino, Italy
* This file generated by SGT on 15-Feb-2023
*************************************************************

*************************************************************
* Evaluating the channel response for testcase IBM_topology_2
*************************************************************

*************************************************************
* Include netlist with all components
*.include ibm_topology_2.cir
*.include ibm_topology_2_DFE.cir
*.include ibm_topology_2_CTLE.cir
.include ibm_topology_2_FFE.cir
*************************************************************

*************************************************************
* Directives for simulation
*************************************************************
*.step param Rs 10 100 10
*.step param Cd 0.1p 1p 0.1p

* 5 Gbps
*.TRAN 0 40n 400p

* 10 Gbps
*.TRAN 0 20n 275p

* 25 Gbps
*.TRAN 0 10n 200p

.TRAN 2n
*.PROBE V(N_3p) V(SUM) V(CTLE_OUT)

*Measures
.opt  plotwinsize=0
.param TB=0.2e-9
.meas TRAN vmax MAX V(N_3p)
.meas TRAN T0 FIND time WHEN V(N_3p)=vmax
.MEAS TRAN bit_2 FIND V(N_3p) AT=T0-(2*TB)
.MEAS TRAN bit_1 FIND V(N_3p) AT=T0-(1*TB)
.MEAS TRAN bit0 FIND V(N_3p) AT=T0
.MEAS TRAN bit1 FIND V(N_3p) AT=T0+(1*TB)
.MEAS TRAN bit2 FIND V(N_3p) AT=T0+(2*TB)
.MEAS TRAN bit3 FIND V(N_3p) AT=T0+(3*TB)
.MEAS TRAN bit4 FIND V(N_3p) AT=T0+(4*TB)
.MEAS TRAN bit5 FIND V(N_3p) AT=T0+(5*TB)
.MEAS TRAN bit6 FIND V(N_3p) AT=T0+(6*TB)
.MEAS TRAN bit7 FIND V(N_3p) AT=T0+(7*TB)

.end

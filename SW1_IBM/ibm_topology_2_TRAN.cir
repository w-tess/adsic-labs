*************************************************************
* 01AUXPE Advanced DEsign for Signal Integrity and Compliance
* Stefano Grivet-Talocia, DET Politecnico di Torino, Italy
* This file generated by SGT on 15-Feb-2023
*************************************************************

*************************************************************
* Evaluating the channel response for testcase IBM_topology_2
*************************************************************

*************************************************************
* Include netlist with all components
*.include ibm_topology_2.cir
.include ibm_topology_2_PRBS.cir
*.include ibm_topology_2_PRBS_FFE.cir
*.include ibm_topology_2_DFE.cir
*.include ibm_topology_2_PRBS_DFE.cir
*************************************************************

*************************************************************
* Directives for simulation
*************************************************************
*.step param RS 10 100 10
*.opt  plotwinsize=0
.TRAN 20n
*.TRAN 1.5n
*.PROBE V(N_3p) V(N_4p) V(SUM) V(COMP)

.end

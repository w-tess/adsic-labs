*************************************************************
* 01AUXPE Advanced DEsign for Signal Integrity and Compliance
* Stefano Grivet-Talocia, DET Politecnico di Torino, Italy
* This file generated by SGT on 15-Feb-2023
*************************************************************

*************************************************************
* Evaluating the channel response for testcase IBM_topology_1
*************************************************************

*************************************************************
* Include netlist with all components
.include ibm_topology_1.cir
*************************************************************

*************************************************************
* Directives for simulation
*************************************************************

.AC LIN 2001 0.02G 40G
.STEP PARAM ph 0 180 30
.PROBE V(D_1p) V(D_2p) V(D_3p) V(D_4p) V(D_5p) V(D_6p)

.end

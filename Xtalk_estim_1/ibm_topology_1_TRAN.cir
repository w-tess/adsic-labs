*************************************************************
* 01AUXPE Advanced DEsign for Signal Integrity and Compliance
* Stefano Grivet-Talocia, DET Politecnico di Torino, Italy
* This file generated by SGT on 15-Feb-2023
*************************************************************

*************************************************************
* Evaluating the channel response for testcase IBM_topology_1
*************************************************************

*************************************************************
* Include netlist with all components
.include ibm_topology_1.cir
*************************************************************

*************************************************************
* Directives for simulation
*************************************************************

.TRAN 20n
*.STEP PARAM R_s LIST 10 30
*.STEP PARAM R_d LIST 85 50
.SAVE V(D_1p) V(D_2p) V(D_3p) V(D_4p) V(D_5p) V(D_6p)

.end
